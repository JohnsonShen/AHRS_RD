# Keil uVision project AHRS_RDM4.uvproj, settings and files
target AHRS_RDM4 (ARM-ADS)
  device: M453VG6AE Nuvoton
  cpu: IRAM(0x20000000-0x20007FFF) IROM(0-0x3FFFF) CLOCK(50000000) CPUTYPE("Cortex-M4") FPU2
  output: AHRS_RDM4
  AfterMake: fromelf --bin ".\obj\@L.axf" --output ".\obj\@L.bin"
  AfterMake: fromelf --text -c ".\obj\@L.axf" --output ".\obj\@L.txt"
  c flags: wLevel=2
  c define: M451
  c include: ..\..\..\Library\Device\Nuvoton\M451Series\Include;..\..\..\Library\StdDriver\inc;.\include;..\AHRSLib\include
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x8000
  link misc: --map --first='startup_M451series.o(RESET)' --datacompressor=off --info=inline --entry Reset_Handler
  group CMSIS
    ../../../Library/Device/Nuvoton/M451Series/Source/: system_M451Series.c
    ../../../Library/Device/Nuvoton/M451Series/Source/ARM/: startup_M451Series.s
  group User
    ./: ak8975.c Calibrate.c FlashCtrl.c FUSIONSDK.c hmc5883l.c I2Cdev.c MPU6050.c NVT_I2C.c Report.c Sensors.c Timer_Ctrl.c LED.c
  group Library
    ../../../Library/StdDriver/src/: gpio.c i2c.c timer.c sys.c uart.c clk.c fmc.c
    ../AHRSLib/obj/: AHRSLibM4.lib
    ./: retargetM4.c
  group Include
    ./: ak8975.h Calibrate.h Config.h Def.h FlashCtrl.h hmc5883l.h I2CDev.h MPU6050.h NVT_I2C.h Report.h retarget.h Sensors.h Timer_Ctrl.h
    ../AHRSLib/include/: AHRSLib.h
